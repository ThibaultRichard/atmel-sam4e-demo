# IAR project sam4e_ek_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HTTP_USED=1; FREERTOS_USED; __SAM4E16E__; __FREERTOS__; BOARD=SAM4E_EK; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\drivers\spi; ..\..; ..\..\..\..\utils\fpu; ..\..\..\..\..\common\services\ioport; ..\..\..\..\..\thirdparty\freertos\freertos-7.3.0\source\include; ..\..\..\..\utils; ..\..\..\..\..\thirdparty\lwip\lwip-1.4.1\src\include\lwip; ..\..\..\..\..\common\services\spi; ..\..\..\..\components\display\ili93xx; ..\..\..\..\drivers\gmac; ..\..\..\..\..\common\services\twi; ..\..\..\..\drivers\tc; ..\..\..\..\drivers\uart; ..\..\..\..\drivers\afec; ..\..\..\..\drivers\pmc; ..\..\..\..\drivers\pdc; ..\..\..\..\utils\preprocessor; ..\..\..\..\..\common\utils; ..\..\..\..\..\common\services\delay; ..\..\..\..\..\thirdparty\lwip\lwip-port-1.4.1\sam\include; ..\..\..\..\drivers\pio; ..\..\..\..\utils\cmsis\sam4e\include; ..\..\..\..\drivers\twi; ..\..\..\..\..\common\boards; ..\..\network\httpserver_raw; ..\..\..\..\utils\cmsis\sam4e\source\templates; ..\..\..\..\components\resistive_touch\ads7843; ..\..\..\..\boards; ..\..\..\..\drivers\dacc; ..\..\..\..\..\thirdparty\lwip\lwip-1.4.1\src\include\ipv4; ..; ..\..\..\..\..\thirdparty\lwip\lwip-port-1.4.1\sam\include\netif; ..\..\..\..\..\common\services\clock; ..\..\..\..\services\resistive_touch; ..\..\..\..\..\thirdparty\lwip\lwip-1.4.1\src\include; ..\..\..\..\..\thirdparty\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\drivers\ebi\smc; ..\..\..\..\..\common\services\gpio; ..\..\..\..\..\common\components\touch\qt\qt_i2c\device_specific; ..\..\..\..\utils\header_files; ..\..\..\..\boards\sam4e_ek; ..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\common\components\touch\qt\qt_i2c; ..\..\..\..\drivers\pdc\pdc_uart_example; ..\..\..\..\..\common\services\serial; ..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\drivers\rstc; ..\..\..\..\..\common\services\spi\sam_spi; ..\..\..\..\components\display\aat31xx; ..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\components\ethernet_phy\ksz8051mnl; ..\..\network; ..\..\..\..\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4e_ek_demo_flash.bin
  ILINK.IlinkOutputFile: sam4e_ek_demo_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\utils\linker_scripts\sam4e\sam4e16\iar\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.1/src/core
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/core/: sys.c def.c dhcp.c udp.c pbuf.c tcp_in.c mem.c memp.c raw.c netif.c tcp.c dns.c lwip_timers_141.c stats.c lwip_init.c tcp_out.c
  group thirdparty/lwip/lwip-1.4.1/src/core/ipv4
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/core/ipv4/: igmp.c ip_addr.c ip.c ip_frag.c icmp.c autoip.c inet.c inet_chksum.c
  group thirdparty/lwip/lwip-1.4.1/src/api
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/api/: netbuf.c tcpip.c err.c api_lib.c sockets.c api_msg.c netifapi.c netdb.c
  group thirdparty/lwip/lwip-1.4.1/src/netif
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.1/src/include/lwip
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/include/lwip/: snmp.h def.h memp_std.h opt.h api_msg.h dns.h mem.h snmp_asn1.h sys.h pbuf.h snmp_structs.h netbuf.h stats.h tcp_impl.h raw.h netifapi.h sockets.h err.h tcp.h arch.h api.h memp.h dhcp.h netif.h debug.h udp.h init.h timers.h snmp_msg.h tcpip.h sio.h netdb.h
  group thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/include/ipv4/lwip/: ip_addr.h icmp.h ip_frag.h inet_chksum.h ip.h autoip.h inet.h igmp.h
  group thirdparty/lwip/lwip-1.4.1/src/include/netif
    ../../../../../thirdparty/lwip/lwip-1.4.1/src/include/netif/: ppp_oe.h etharp.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/netif
    ../../../../../thirdparty/lwip/lwip-port-1.4.1/sam/netif/: sam4e_gmac.c
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/netif
    ../../../../../thirdparty/lwip/lwip-port-1.4.1/sam/include/netif/: sam4e_gmac.h
  group thirdparty/lwip/lwip-port-1.4.1/sam/include/arch
    ../../../../../thirdparty/lwip/lwip-port-1.4.1/sam/include/arch/: perf.h cc.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../thirdparty/freertos/freertos-7.3.0/source/: queue.c list.c tasks.c timers.c FreeRTOS_CLI.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../thirdparty/freertos/freertos-7.3.0/source/include/: task.h list.h portable.h FreeRTOS_CLI.h mpu_wrappers.h croutine.h StackMacros.h projdefs.h timers.h queue.h semphr.h FreeRTOS.h
  group sam/applications/sam4e_ek_demo
    ../../: main.c task_webserver.c task_dsp.c task_qtouch_cpn.c task_gfx.c logo_atmel.h task_demo.h sound.h lwipopts.h FreeRTOSConfig.h
  group sam/applications/sam4e_ek_demo/network
    ../../network/: timer_mgt_sam.c ethernet_sam.c timer_mgt_sam.h ethernet_sam.h
  group sam/applications/sam4e_ek_demo/network/httpserver_raw
    ../../network/httpserver_raw/: fsdata.c httpd.c fs.c cgi.c favicon.h cgi.h style.h jqflot.h atmel.h index.h fsdata.h httpd.h fs.h excan.h jquery.h
  group sam/applications/sam4e_ek_demo/sam4e16e_sam4e_ek
    ../: conf_spi_master.h conf_ads7843.h conf_aat31xx.h conf_clock.h conf_eth.h conf_sleepmgr.h conf_qt_i2c.h conf_board.h conf_ili93xx.h conf_uart_serial.h
  group sam/applications/sam4e_ek_demo/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/afec
    ../../../../drivers/afec/: afec.c afec.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/rstc
    ../../../../drivers/rstc/: rstc.c rstc.h
  group sam/drivers/rstc/example1
    ../../../../drivers/rstc/example1/: rstc_example1.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/gmac
    ../../../../drivers/gmac/: gmac_phy.c gmac.h
  group sam/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/dacc
    ../../../../drivers/dacc/: dacc.c dacc.h
  group sam/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/twi
    ../../../../drivers/twi/: twi.c twi.h
  group sam/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../utils/cmsis/sam4e/include/: sam4e8e.h sam4e16c.h sam4e16e.h sam4e16cb.h sam4e8c.h sam4e8cb.h sam4e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../utils/cmsis/sam4e/include/instance/: smc.h rswdt.h efc.h can0.h rstc.h afec0.h wdt.h usart1.h pwm.h chipid.h spi.h piob.h afec1.h tc0.h can1.h dacc.h piod.h acc.h tc1.h usart0.h pioe.h rtc.h gpbr.h pioa.h aes.h supc.h twi0.h twi1.h hsmci.h uart0.h pioc.h pmc.h tc2.h rtt.h cmcc.h gmac.h udp.h matrix.h uart1.h dmac.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../utils/cmsis/sam4e/include/component/: rtc.h afec.h pio.h usart.h cmcc.h aes.h efc.h hsmci.h rtt.h udp.h dacc.h smc.h chipid.h uart.h rstc.h spi.h tc.h wdt.h gpbr.h twi.h rswdt.h dmac.h acc.h pwm.h supc.h matrix.h can.h pdc.h gmac.h pmc.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../utils/cmsis/sam4e/include/pio/: sam4e8c.h sam4e16cb.h sam4e8e.h sam4e8cb.h sam4e16e.h sam4e16c.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: tpaste.h stringz.h preprocessor.h mrepeat.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/components/resistive_touch/ads7843
    ../../../../components/resistive_touch/ads7843/: ads7843.c ads7843.h
  group sam/components/display/ili93xx
    ../../../../components/display/ili93xx/: ili93xx.c ili9341_regs.h ili9325_regs.h ili93xx.h
  group sam/components/display/aat31xx
    ../../../../components/display/aat31xx/: aat31xx.c aat31xx.h
  group sam/components/ethernet_phy
    ../../../../components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../components/ethernet_phy/ksz8051mnl/: ethernet_phy.c ethernet_phy.h
  group sam/boards/sam4e_ek
    ../../../../boards/sam4e_ek/: init.c led.h sam4e_ek.h
  group sam/services/resistive_touch
    ../../../../services/resistive_touch/: rtouch.c rtouch_ads7843.h rtouch.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/twi
    ../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/touch/qt/qt_i2c
    ../../../../../common/components/touch/qt/qt_i2c/: qt_i2c.c qt_i2c.h
  group common/components/touch/qt/qt_i2c/device_specific
    ../../../../../common/components/touch/qt/qt_i2c/device_specific/: QT2160.h
  group common/boards
    ../../../../../common/boards/: board.h
